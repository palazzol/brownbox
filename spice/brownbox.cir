.title KiCad schematic
R1 A VCC 2K
R4 Net-_D1-Pad2_ GNDREF 2K
R6 Net-_C2-Pad1_ GNDREF 220K
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 390pF
C2 Net-_C2-Pad1_ Net-_C2-Pad2_ 330pF
R3 Net-_D1-Pad2_ Net-_C1-Pad2_ 2K
R2 Net-_C2-Pad2_ A 2K
Q1 GNDREF Net-_C1-Pad1_ A 2N5134
RV1 VCC Net-_R5-Pad1_ Net-_R5-Pad1_ 100K
Q2 VCC Net-_C2-Pad1_ Net-_D1-Pad2_ 2N5139
R5 Net-_R5-Pad1_ Net-_C1-Pad1_ 150K
R7 B VCC 2K
R10 S11C2 GNDREF 2K
R12 Net-_C4-Pad1_ GNDREF 220K
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 0.1uF
C4 Net-_C4-Pad1_ Net-_C4-Pad2_ 0.2uF
R9 S11C2 Net-_C3-Pad2_ 2K
R8 Net-_C4-Pad2_ B 2K
Q3 GNDREF Net-_C3-Pad1_ B 2N5134
RV2 VCC Net-_R11-Pad1_ Net-_R11-Pad1_ 100K
R11 Net-_R11-Pad1_ Net-_C3-Pad1_ 150K
D1 Net-_C7-Pad1_ Net-_D1-Pad2_ 1N4148
R15 Net-_C7-Pad1_ Net-_C5-Pad1_ 10K
C5 Net-_C5-Pad1_ GNDREF 100uF
C7 Net-_C7-Pad1_ Net-_C7-Pad2_ 750pF
R17 VCC Net-_C7-Pad2_ 130K
D2 Net-_C11-Pad1_ S11D1 1N4148
R16 Net-_C11-Pad1_ Net-_C6-Pad1_ 10K
C6 Net-_C6-Pad1_ GNDREF 100uF
C8 Net-_C11-Pad1_ Net-_C8-Pad2_ 0.1uF
R18 VCC Net-_C8-Pad2_ 270K
Q5 GNDREF Net-_C7-Pad2_ Net-_C9-Pad1_ 2N5134
Q6 GNDREF Net-_C9-Pad2_ Net-_D22-Pad2_ 2N5134
Q8 GNDREF Net-_C10-Pad2_ Net-_D22-Pad2_ 2N5134
Q7 GNDREF Net-_C8-Pad2_ Net-_C10-Pad1_ 2N5133
C9 Net-_C9-Pad1_ Net-_C9-Pad2_ 130pF
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ 0.1uF
R19 VCC Net-_C9-Pad1_ 10K
R24 Net-_R23-Pad2_ Net-_D22-Pad2_ 10K
R21 VCC Net-_C9-Pad2_ 33K
R20 VCC Net-_C10-Pad1_ 10K
R22 VCC Net-_C10-Pad2_ 15K
R23 VCC Net-_R23-Pad2_ 2K
C11 Net-_C11-Pad1_ Net-_C10-Pad2_ 0.01uF
R13 S15A1 Net-_C5-Pad1_ 2K
R14 S15B1 Net-_C6-Pad1_ 2K
D3 Net-_C14-Pad1_ Net-_D1-Pad2_ 1N4148
R27 Net-_C14-Pad1_ Net-_C12-Pad1_ 10K
C12 Net-_C12-Pad1_ GNDREF 100uF
C14 Net-_C14-Pad1_ Net-_C14-Pad2_ 750pF
R29 VCC Net-_C14-Pad2_ 130K
D4 Net-_C15-Pad1_ S11C1 1N4148
R28 Net-_C15-Pad1_ Net-_C13-Pad1_ 10K
C13 Net-_C13-Pad1_ GNDREF 100uF
C15 Net-_C15-Pad1_ Net-_C15-Pad2_ 0.1uF
R30 VCC Net-_C15-Pad2_ 270K
Q9 GNDREF Net-_C14-Pad2_ Net-_C16-Pad1_ 2N5134
Q10 GNDREF Net-_C16-Pad2_ Net-_D21-Pad2_ 2N5134
Q12 GNDREF Net-_C17-Pad2_ Net-_D21-Pad2_ 2N5134
Q11 GNDREF Net-_C15-Pad2_ Net-_C17-Pad1_ 2N5133
C16 Net-_C16-Pad1_ Net-_C16-Pad2_ 130pF
C17 Net-_C17-Pad1_ Net-_C17-Pad2_ 0.1uF
R31 VCC Net-_C16-Pad1_ 10K
R36 S1A3 Net-_D21-Pad2_ 10K
R33 VCC Net-_C16-Pad2_ 33K
R32 VCC Net-_C17-Pad1_ 10K
R34 VCC Net-_C17-Pad2_ 15K
R35 VCC S1A3 2K
C18 Net-_C15-Pad1_ Net-_C17-Pad2_ 0.01uF
R25 S15C1 Net-_C12-Pad1_ 2K
R26 S15D1 Net-_C13-Pad1_ 2K
D7 Net-_C25-Pad1_ Net-_D1-Pad2_ 1N4148
R49 Net-_C25-Pad1_ S9D1 10K
C25 Net-_C25-Pad1_ Net-_C25-Pad2_ 750pF
R54 VCC Net-_C25-Pad2_ 130K
D8 Net-_C26-Pad1_ S11C1 1N4148
C26 Net-_C26-Pad1_ Net-_C26-Pad2_ 0.1uF
R55 VCC Net-_C26-Pad2_ 270K
Q17 GNDREF Net-_C25-Pad2_ Net-_C27-Pad1_ 2N5134
Q18 GNDREF Net-_C27-Pad2_ S1B2 2N5134
Q20 GNDREF Net-_Q19-Pad3_ S1B1 2N5134
Q19 GNDREF Net-_C26-Pad2_ Net-_Q19-Pad3_ 2N5133
C27 Net-_C27-Pad1_ Net-_C27-Pad2_ 130pF
R56 VCC Net-_C27-Pad1_ 10K
R60 VCC S1B2 10K
R58 VCC Net-_C27-Pad2_ 22K
R57 VCC Net-_Q19-Pad3_ 10K
R50 GNDREF S9D1 5.1K
R53 GNDREF Net-_C26-Pad1_ 10K
R59 Net-_C26-Pad1_ VCC 5.1K
R51 S9D1 VCC 5.1K
RV8 VCC Net-_R52-Pad1_ GNDREF 10K
R52 Net-_R52-Pad1_ S9D3 220
Q31 GNDREF S2D3 S2A3 2N5133
R91 S2D3 S2A3 51K
R89 VCC S2A3 5.1K
Q32 GNDREF Net-_Q32-Pad2_ S2B3 2N5133
R92 Net-_Q32-Pad2_ S2B3 51K
R90 VCC S2B3 5.1K
D5 S16A1 Net-_D1-Pad2_ 1N4148
C19 Net-_C19-Pad1_ GNDREF 100uF
C21 S16A1 Net-_C21-Pad2_ 750pF
R41 VCC Net-_C21-Pad2_ 130K
D6 S16B1 S11C1 1N4148
R40 S16B2 Net-_C20-Pad1_ 10K
C20 Net-_C20-Pad1_ GNDREF 100uF
C22 S16B1 Net-_C22-Pad2_ 0.1uF
R42 VCC Net-_C22-Pad2_ 270K
Q13 GNDREF Net-_C21-Pad2_ Net-_C23-Pad1_ 2N5134
Q14 GNDREF Net-_C23-Pad2_ S3A3 2N5134
Q16 GNDREF Net-_C24-Pad2_ S3A3 2N5134
Q15 GNDREF Net-_C22-Pad2_ Net-_C24-Pad1_ 2N5133
C23 Net-_C23-Pad1_ Net-_C23-Pad2_ 130pF
C24 Net-_C24-Pad1_ Net-_C24-Pad2_ 0.1uF
R43 VCC Net-_C23-Pad1_ 10K
R48 S1A2 S3A3 10K
R45 VCC Net-_C23-Pad2_ 33K
R44 VCC Net-_C24-Pad1_ 10K
R46 VCC Net-_C24-Pad2_ 15K
R47 VCC S1A2 2K
R37 S7A1 Net-_C19-Pad1_ 2K
R38 S7B1 Net-_C20-Pad1_ 2K
R39 S16A2 Net-_C19-Pad1_ 10K
RV4 S7A2 S9B1 S9B1 5K
RV3 GNDREF S7A3 VCC 10K
RV5 GNDREF S7B3 VCC 10K
RV6 d S7B2 a 25K
RV7 b S7B2 c 25K
Q23 GNDREF F Net-_C31-Pad2_ 2N5133
Q21 GNDREF E Net-_C30-Pad1_ 2N5133
Q22 VCC Net-_C29-Pad1_ Net-_C28-Pad1_ 2N5139
Q24 VCC Net-_C28-Pad2_ Net-_C29-Pad2_ 2N5139
R68 Net-_C29-Pad2_ S9B3 1K
R69 S9B3 Net-_C31-Pad2_ 1K
R67 Net-_C28-Pad1_ Net-_C30-Pad1_ 2K
R61 Net-_C28-Pad1_ Net-_C28-Pad2_ 22K
R63 Net-_C29-Pad1_ Net-_C29-Pad2_ 22K
R62 Net-_C30-Pad1_ F 22K
R64 E Net-_C31-Pad2_ 22K
C28 Net-_C28-Pad1_ Net-_C28-Pad2_ 0.1uF
C30 Net-_C30-Pad1_ F 100pF
C29 Net-_C29-Pad1_ Net-_C29-Pad2_ 0.1uF
C31 E Net-_C31-Pad2_ 100pF
D11 a Net-_C28-Pad1_ 1N270
D14 Net-_C31-Pad2_ d 1N270
D13 c Net-_C29-Pad2_ 1N270
D12 Net-_C30-Pad1_ b 1N270
R65 E Net-_D9-Pad1_ 10K
R66 F Net-_D10-Pad1_ 10K
D9 Net-_D9-Pad1_ S8A2 1N4148
D10 Net-_D10-Pad1_ S8B2 1N4148
Q27 GNDREF F' Net-_C35-Pad2_ 2N5133
Q26 S9A2 Net-_C33-Pad1_ Net-_C32-Pad1_ 2N5139
Q28 S9A2 Net-_C32-Pad2_ Net-_C33-Pad2_ 2N5139
R77 Net-_C33-Pad2_ S9B2 1K
R78 S9B2 Net-_C35-Pad2_ 1K
R76 Net-_C32-Pad1_ Net-_C34-Pad1_ 2K
R70 Net-_C32-Pad1_ Net-_C32-Pad2_ 22K
R72 Net-_C33-Pad1_ Net-_C33-Pad2_ 22K
R71 Net-_C34-Pad1_ F' 22K
R73 E' Net-_C35-Pad2_ 22K
C32 Net-_C32-Pad1_ Net-_C32-Pad2_ 0.1uF
C34 Net-_C34-Pad1_ F' 100pF
C33 Net-_C33-Pad1_ Net-_C33-Pad2_ 0.1uF
C35 E' Net-_C35-Pad2_ 100pF
R75 E' Net-_D16-Pad1_ 10K
D16 Net-_D16-Pad1_ S8B2 1N4148
Q25 GNDREF E' Net-_C34-Pad1_ 2N5133
R74 E' Net-_D15-Pad1_ 10K
D15 Net-_D15-Pad1_ S8A2 1N4148
Q34 GNDREF Net-_C38-Pad2_ Net-_D24-Pad2_ 2N5133
Q33 GNDREF Net-_C39-Pad1_ Net-_C38-Pad1_ 2N5133
R98 Net-_C39-Pad1_ Net-_D24-Pad2_ 100K
R97 VCC Net-_D24-Pad2_ 10K
R96 VCC Net-_C38-Pad2_ 510K
R95 VCC Net-_C38-Pad1_ 10K
C38 Net-_C38-Pad1_ Net-_C38-Pad2_ 0.22uF
C39 Net-_C39-Pad1_ Net-_C39-Pad2_ 0.1uF
D23 S2D3 Net-_C38-Pad2_ 1N270
D26 Net-_C39-Pad2_ S2C2 1N4148
R99 Net-_C39-Pad2_ GNDREF 100K
D27 S2C2 S2C2 1N4148
R100 E Net-_D24-Pad1_ 20K
D24 Net-_D24-Pad1_ Net-_D24-Pad2_ 1N4148
R101 F Net-_D25-Pad1_ 20K
D25 Net-_D25-Pad1_ Net-_D24-Pad2_ 1N4148
Q40 S11B3 Net-_D34-Pad2_ Net-_C47-Pad1_ 2N5139
D33 S11B3 Net-_C47-Pad1_ 1N4148
D31 S11B3 S11D3 1N4148
D32 S11D3 S11C3 1N4148
D30 S11D3 Net-_D30-Pad2_ 1N4148
R121 S11B3 Net-_D38-Pad2_ 51K
R122 Net-_D38-Pad1_ Net-_C51-Pad2_ 33K
R110 Net-_D34-Pad1_ Net-_Q37-Pad3_ 10K
D34 Net-_D34-Pad1_ Net-_D34-Pad2_ 1N4148
Q37 GNDREF Net-_D35-Pad1_ Net-_Q37-Pad3_ 2N5133
Q44 GNDREF Net-_C51-Pad1_ Net-_Q44-Pad3_ 2N5133
R123 S11A3 Net-_C51-Pad2_ 10K
R124 S11A3 Net-_Q44-Pad3_ 100K
R126 S11A3 Net-_Q44-Pad3_ 10K
Q45 GNDREF Net-_Q45-Pad2_ Net-_C51-Pad2_ 2N5133
C51 Net-_C51-Pad1_ Net-_C51-Pad2_ 0.3uF
R128 Net-_Q42-Pad3_ S11A3 5.1K
R133 S11C3 GNDREF 2K
C53 Net-_C53-Pad1_ Net-_C53-Pad2_ 0.1uF
R131 Net-_Q43-Pad2_ Net-_Q42-Pad3_ 2K
Q42 GNDREF Net-_C53-Pad1_ Net-_Q42-Pad3_ 2N5133
R129 Net-_C53-Pad1_ Net-_C50-Pad1_ 5.1K
Q43 S11A3 Net-_Q43-Pad2_ S11C3 2N5139
R132 S11C3 Net-_C53-Pad2_ 2K
R130 GNDREF Net-_C53-Pad1_ 22K
Q39 GNDREF Net-_C48-Pad2_ Net-_C49-Pad2_ 2N5133
Q38 GNDREF Net-_C49-Pad1_ Net-_C48-Pad1_ 2N5133
R115 S11A3 Net-_C49-Pad2_ 10K
R114 S11A3 Net-_C48-Pad1_ 10K
R116 Net-_C48-Pad1_ Net-_C48-Pad2_ 100K
R117 Net-_C49-Pad1_ Net-_C49-Pad2_ 100K
C48 Net-_C48-Pad1_ Net-_C48-Pad2_ 0.01uF
C49 Net-_C49-Pad1_ Net-_C49-Pad2_ 0.01uF
D35 Net-_D35-Pad1_ Net-_D35-Pad2_ 1N4148
R112 Net-_D35-Pad1_ GNDREF 100K
R113 S11A3 Net-_D35-Pad2_ 100K
R111 Net-_Q37-Pad3_ S11A3 10K
D38 Net-_D38-Pad1_ Net-_D38-Pad2_ 1N4148
Q41 S11B3 Net-_D38-Pad2_ Net-_D30-Pad2_ 2N5139
D36 Net-_C48-Pad1_ Net-_D36-Pad2_ 1N4148
J3 Net-_D36-Pad2_ Net-_D35-Pad2_ Jumper
D37 Net-_D37-Pad1_ Net-_C47-Pad2_ 1N4148
R118 Net-_C49-Pad1_ Net-_D37-Pad1_ 100K
R119 Net-_D37-Pad1_ Net-_C48-Pad2_ 100K
R120 Net-_C47-Pad2_ GNDREF 10K
C47 Net-_C47-Pad1_ Net-_C47-Pad2_ 0.1uF
C50 Net-_C50-Pad1_ Net-_C47-Pad1_ 0.01uF
R127 Net-_C52-Pad1_ Net-_Q45-Pad2_ 51K
C52 Net-_C52-Pad1_ Net-_C49-Pad2_ 0.1uF
Q29 GNDREF Net-_Q29-Pad2_ Net-_Q29-Pad3_ 2N5134
R83 Net-_Q29-Pad3_ Net-_Q29-Pad2_ 10K
R85 VCC Net-_Q29-Pad3_ 2K
R86 Net-_C37-Pad2_ Net-_Q29-Pad3_ 10K
R82 Net-_Q29-Pad2_ Net-_D17-Pad2_ 12K
R84 GNDREF Net-_Q29-Pad2_ 1.8K
Q30 GNDREF Net-_C36-Pad1_ Net-_C37-Pad2_ 2N5134
R87 Net-_C36-Pad1_ Net-_C37-Pad2_ 150K
C37 Net-_C37-Pad1_ Net-_C37-Pad2_ 180pF
C36 Net-_C36-Pad1_ GNDREF 82pF
L1 Net-_C36-Pad1_ Net-_C37-Pad1_ 4 Turns, #16 brass
R88 Net-_L2-Pad1_ NC_01 270
D19 Net-_D17-Pad2_ S1B2 1N4148
D20 Net-_D17-Pad2_ S3A3 1N4148
D21 Net-_D17-Pad2_ Net-_D21-Pad2_ 1N4148
D22 Net-_D17-Pad2_ Net-_D22-Pad2_ 1N4148
D18 B Net-_D17-Pad2_ 1N4148
R81 Net-_Q29-Pad2_ B 100K
D17 A Net-_D17-Pad2_ 1N4148
R80 Net-_Q29-Pad2_ A 100K
R79 Net-_Q29-Pad2_ S 5.1K
Q35 GNDREF Net-_C40-Pad2_ Net-_C42-Pad1_ 2N5134
RV9 Net-_C43-Pad2_ Net-_C44-Pad2_ Net-_C44-Pad2_ 5K
CV2 Net-_C42-Pad1_ Net-_CV2-Pad2_ 9-35pF
C42 Net-_C42-Pad1_ S12A3 62pF
T1 S12A3 Net-_C42-Pad1_ Net-_C44-Pad1_ GNDREF Net-_C43-Pad1_ CF104 core, #22 wire
C44 Net-_C44-Pad1_ Net-_C44-Pad2_ 56pF
C43 Net-_C43-Pad1_ Net-_C43-Pad2_ 180pF
R102 S12A3 Net-_C40-Pad2_ 300K
X1 Net-_C40-Pad2_ Net-_CV2-Pad2_ 3.579545Mhz
C41 GNDREF S12A3 0.01uF
R103 S12A3 Net-_C43-Pad2_ 10K
R104 Net-_C43-Pad2_ GNDREF 10K
D29 Net-_C44-Pad2_ Net-_C46-Pad2_ 1N4148
D28 Net-_C46-Pad2_ Net-_C43-Pad2_ 1N4148
C46 S Net-_C46-Pad2_ 120pF
R107 Net-_Q36-Pad3_ Net-_C46-Pad2_ 6.2K
R106 S12A3 Net-_Q36-Pad3_ 6.2K
Q36 GNDREF Net-_C45-Pad2_ Net-_Q36-Pad3_ 2N5134
R109 GNDREF Net-_C45-Pad2_ 15K
C45 GNDREF Net-_C45-Pad2_ 360pF
R108 Net-_C45-Pad2_ A 51K
C40 GNDREF Net-_C40-Pad2_ 27pF
D45 Net-_D45-Pad1_ Net-_D43-Pad2_ 1N4148
R139 Net-_D45-Pad1_ S9C1 10K
D43 S3A3 Net-_D43-Pad2_ 1N270
D44 S1B2 Net-_D43-Pad2_ 1N270
R138 VCC Net-_D43-Pad2_ 5.1K
R136 S8B2 VCC 5.1K
R137 S8A2 VCC 5.1K
D39 S3A3 S8B2 1N270
D40 S3A3 S8A2 1N270
D41 Net-_D22-Pad2_ S8A1 1N270
D42 Net-_D21-Pad2_ S8B1 1N270
D46 S2C2 S8A3 1N4148
R140 S8C3 S8A3 10K
SCR1 S2D2 S2C2 GNDREF NT854
R141 S2C2 GNDREF 10K
Q46 GNDREF Net-_D47-Pad1_ S2D2 2N5133
D47 Net-_D47-Pad1_ Net-_D47-Pad2_ 1N4148
D48 Net-_D47-Pad1_ Net-_D48-Pad2_ 1N4148
R142 VCC Net-_D47-Pad2_ 22K
R143 VCC Net-_D48-Pad2_ 22K
R144 VCC Net-_R144-Pad2_ 1K
R145 Net-_R145-Pad1_ GNDREF 1K
R146 Net-_R146-Pad1_ S4A3 100
R147 S4A3 Net-_R147-Pad2_ 100
R148 S4A3 GNDREF 150K
C54 Net-_C54-Pad1_ GNDREF 10uF
C55 Net-_C55-Pad1_ GNDREF 10uF
RV12 VCC S2A2 GNDREF 5K
RV11 VCC D GNDREF 5K
RV13 VCC S4A2 GNDREF 5K
RV10 VCC C GNDREF 5K
S19 VCC Net-_BT1-Pad1_ POWER
BT1 Net-_BT1-Pad1_ GNDREF 4 D Cells
BT2 Net-_BT2-Pad1_ Net-_BT2-Pad2_ 1 C Cell
J1 Net-_BT2-Pad1_ S2D1 S2C1 VCC GNDREF Net-_BT2-Pad2_ GNDREF Rifle Connector - C7-205
J2 S15A3 S15B3 S15C3 S15D3 Net-_J2-PadE_ Net-_J2-PadF_ Net-_J2-PadG_ Net-_J2-PadG_ S8B2 S8A2 VCC GNDREF 12-Pin Cinch Jones Expansion Connector
R134 Net-_J2-PadE_ S16A3 10K
R135 Net-_J2-PadF_ S16B3 10K
C56 S2C2 S2C1 0.02uF
S1 Net-_S1-PadA1_ S1A2 S1A3 S1B1 S1B2 NC_02 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 SW_Slide_4PDT
S2 S15C2 S2A2 S2A3 S15D2 Net-_S2-PadB2_ S2B3 S2C1 S2C2 S2C3 S2D1 S2D2 S2D3 SW_Slide_4PDT
S3 Net-_S3-PadA1_ GNDREF S3A3 S1B2 GNDREF NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 SW_Slide_4PDT
S4 Net-_S2-PadB2_ S4A2 S4A3 NC_16 NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 SW_Slide_4PDT
S5 S2D2 NC_25 Net-_S1-PadA1_ NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 NC_33 NC_34 SW_Slide_4PDT
S6 Net-_S3-PadA1_ NC_35 GNDREF NC_36 NC_37 NC_38 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 SW_Slide_4PDT
S7 S7A1 S7A2 S7A3 S7B1 S7B2 S7B3 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 SW_Slide_4PDT
S8 S8A1 S8A2 S8A3 S8B1 S8B2 S8A3 VCC NC_51 S8C3 NC_52 NC_53 NC_54 SW_Slide_4PDT
S9 VCC S9A2 NC_55 S9B1 S9B2 S9B3 S9C1 F' S2C2 S9D1 NC_56 S9D3 SW_Slide_4PDT
S10 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 SW_Slide_4PDT
S11 VCC NC_69 S11A3 S11C2 NC_70 S11B3 S11C1 S11C2 S11C3 S11D1 S11C2 S11D3 SW_Slide_4PDT
S12 VCC NC_71 S12A3 NC_72 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 NC_79 NC_80 SW_Slide_4PDT
S13 NC_81 NC_82 NC_83 NC_84 NC_85 NC_86 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 SW_Slide_4PDT
S14 NC_93 NC_94 NC_95 NC_96 NC_97 NC_98 NC_99 NC_100 NC_101 NC_102 NC_103 NC_104 SW_Slide_4PDT
S15 S15A1 C S15A3 S15B1 D S15B3 S15C1 S15C2 S15C3 S15D1 S15D2 S15D3 SW_Slide_4PDT
S16 S16A1 S16A2 S16A3 S16B1 S16B2 S16B3 NC_105 NC_106 NC_107 NC_108 NC_109 NC_110 SW_Slide_4PDT
R125 Net-_Q44-Pad3_ Net-_Q45-Pad2_ 100K
CV1 Net-_C37-Pad1_ GNDREF 9-35pF
S17 NC_111 NC_112 E' GNDREF Net-_D48-Pad2_ GNDREF E GNDREF Net-_R144-Pad2_ Net-_C54-Pad1_ Net-_R146-Pad1_ Net-_C54-Pad1_ SW_Push_3PDT
S18 NC_113 NC_114 F' GNDREF Net-_D47-Pad2_ GNDREF F GNDREF Net-_R145-Pad1_ Net-_C55-Pad1_ Net-_R147-Pad2_ Net-_C55-Pad1_ SW_Push_3PDT
Q4 VCC Net-_C4-Pad1_ S11C2 2N5139
R94 Net-_Q32-Pad2_ GNDREF 12K
R93 S2C3 Net-_Q32-Pad2_ 10K
L2 Net-_L2-Pad1_ NC_115 L
.end
